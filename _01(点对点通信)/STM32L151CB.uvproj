# Keil uVision project STM32L151CB.uvproj, settings and files
target IntoRobo L6 (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L151CB
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L15XXB_128K,USE_STDPERIPH_DRIVER
  c include: .\_01_App;.\_02_User;.\_03_OS;.\_05_Drive;.\_06_Library\inc;.\_08_Material;.\_06_Library\CMSIS;.\_04_LoRa\platform;.\_04_LoRa\radio
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./_01_App/: App_Lora.c App_LED.c App_Test.c App_Infrared.c App_Key.c
  group User
    ./_02_User/: main.c User_Bsp.c User_Library.h User_Stdafx.h
  group OS
    ./_03_OS/: OS_Manage.c OS_Run.c OS_StartFile.c OS_Tools.c
  group Drive
    ./_05_Drive/: Drive_SX1276.c Drive_Infrared.c Drive_LED.c Drive_EXTI.c Drive_GPIO.c Drive_Interrupt.c Drive_Timer.c Drive_USART.c Drive_Key.c Drive_RCC.c
  group Lora
    ./_04_LoRa/platform/: platform.c bleeper.c sx1276-Hal.c spi.c fifo.c
    ./_04_LoRa/radio/: sx1276.c radio.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group Library
    ./_06_Library/CMSIS/: startup_stm32l1xx_md.s core_cm3.c system_stm32l1xx.c
    ./_06_Library/src/: misc.c stm32l1xx_rcc.c stm32l1xx_exti.c stm32l1xx_pwr.c stm32l1xx_spi.c stm32l1xx_usart.c stm32l1xx_tim.c stm32l1xx_gpio.c stm32l1xx_syscfg.c
  group Material
    ./_08_Material/: Infrared.c Material.h
  group Doc
    ./_07_Doc/: ReadMe.txt
